# Keil uVision project mdk_bootloader.uvprojx, settings and files
target mdk_bootloader (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: psdk_demo
  AfterMake: D:\soft\keil5\ARM\ARMCC\bin\fromelf.exe .\Objects\psdk_demo.axf --bin --output .\dji_sdk_bootloader.bin
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: -DHSE_VALUE=8000000 --diag_suppress=188,177,550,940,66,546
  c include: ..\..\application;..\..\drivers\BSP;..\..\drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\drivers\CMSIS\Include;..\..\drivers\CMSIS\RTOS;..\..\drivers\STM32F4xx_HAL_Driver\Inc;..\..\;..\..\..\..\..\api_sample;..\..\..\..\..\..\..\psdk_lib\include;..\..\middlewares\Third_Party\FreeRTOS\Source\include;..\..\middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\common\osal
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group bootloader
    ../../bootloader/: common.c main.c menu.c ymodem.c
  group drv/bsp
    ../../Drivers/BSP/: stm32f4xx_it.c dji_ringbuffer.c uart.c
    ../../drivers/BSP/: stm32f4xx_hal_msp.c flash_if.c upgrade_platform_opt_stm32.c button.c
  group drv/cmsis
    ../../drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    ../../drivers/BSP/: system_stm32f4xx.c
  group drv/stm32f4_hal_driver
    ../../drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_usb.c
  group platform/osal
    ../../../common/osal/: osal.c
  group mid/freertos/port
    ../../middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group mid/freertos/src
    ../../middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
